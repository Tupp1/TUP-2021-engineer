# Keil uVision project 2020_SH_RMEngineer_Program.uvprojx, settings and files
target SH_RM_Engineer_Program (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\User;..\User\AHRS;..\User\DSP\Include;..\User\FreeRTOS\include;..\User\FreeRTOS\portable;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\user\user_lib;..\User\hardware\ADC;..\User\hardware\BUZZER;..\User\hardware\delay;..\User\hardware\CAN;..\User\hardware\LED;..\User\hardware\FLASH;..\User\hardware\FRIC;..\User\hardware\LASER;..\User\hardware\POWER_CTRL;..\User\hardware\RC;..\User\hardware\RNG;..\User\hardware\SPI;..\User\hardware\SYS;..\user\hardware\iwdg;..\user\hardware\timer;..\user\hardware\usart;..\user\hardware\pwm;..\user\hardware\power_ctrl;..\User\APP\CAN_Receive;..\User\APP\FreeRTOS_Middleware;..\user\APP\vision_control;..\user\APP\system;..\user\APP\remote;..\user\TASK\calibrate_task;..\user\TASK\INS_task;..\user\TASK\start_task;..\user\TASK\user_task;..\user\TASK\chassis_task;..\user\TASK\Timer_Send_Task;..\user\TASK\gimbal_task;..\user\hardware\exit_init;..\user\AppInfo\Info_update;..\user\APP\control;..\user\APP\CAN_receive;..\user\APP\chassis_behaviour;..\user\TASK\gimbal_task;..\user\APP\gimbal_behaviour;..\user\TASK\Revolver_task;..\user\AppInfo\Info_transmitter;..\user\AppInfo\judge;..\user\AppInfo\vision;..\user\AppInfo\dataset;..\user\TASK\UDTrans_task;..\user\hardware\io
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../startup/: startup_stm32f427xx.s
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group freeRTOS
    ../user/FreeRTOS/: list.c tasks.c timers.c queue.c croutine.c event_groups.c
    ../user/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../user/FreeRTOS/portable/MemMang/: heap_4.c
  group AHRS
    ../user/AHRS/: AHRS.lib ist8310driver.c mpu6500driver.c AHRS_middleware.c ist8310driver_middleware.c mpu6500driver_middleware.c
  group DSP
    ../user/DSP/: arm_cortexM4lf_math.lib
  group user_lib
    ../user/user_lib/: pid.c filter.c ramp.c user_lib.c mymath.c crc_check.c kalman.c kalman_filter.c
  group main
    ../user/: main.c sys_config.h
  group hardware
    ../user/hardware/rc/: rc.c
    ../user/hardware/io/: io.c
    ../user/hardware/spi/: spi.c
    ../user/hardware/led/: led.c
    ../user/hardware/adc/: adc.c
    ../user/hardware/can/: can.c
    ../user/hardware/flash/: flash.c
    ../user/hardware/iwdg/: iwdg.c
    ../user/hardware/usart/: usart.c
    ../user/hardware/pwm/: pwm.c
    ../user/hardware/timer/: timer.c
    ../user/hardware/delay/: delay.c
    ../user/hardware/buzzer/: buzzer.c
    ../user/hardware/exit_init/: exit_init.c
    ../user/hardware/power_ctrl/: power_ctrl.c
  group APP
    ../user/APP/system/: system.c
    ../user/APP/remote/: remote.c
    ../user/APP/control/: control.c
    ../user/APP/CAN_receive/: CAN_receive.c
    ../user/APP/gimbal_behaviour/: gimbal_behaviour.c
    ../user/APP/chassis_behaviour/: chassis_behaviour.c
    ../user/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c
  group APPInfo
    ../user/AppInfo/judge/: judge.c
    ../user/AppInfo/vision/: vision.c
    ../user/AppInfo/dataset/: dataset.c
    ../user/AppInfo/Info_update/: Info_Update.c
    ../user/AppInfo/Info_transmitter/: Info_Transmitter.c
  group TASK
    ../user/TASK/INS_task/: INS_task.c
    ../user/TASK/start_task/: start_task.c
    ../user/TASK/gimbal_task/: gimbal_task.c
    ../user/TASK/chassis_task/: chassis_task.c
    ../user/TASK/calibrate_task/: calibrate_task.c
    ../user/TASK/UDTrans_task/: UDTrans_task.c
    ../user/TASK/Revolver_task/: Revolver_task.c
    ../user/TASK/Timer_Send_Task/: Timer_Send_Task.c
  group Mast Read Me !!!!!
    ../: My thought.txt Some instructions.txt
